# Keil uVision project RMv3testDemo.uvprojx, settings and files
target RMv3testDemo (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RMv3testDemo +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F427xx
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\Drivers\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Hardware\include;..\User\include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --diag_suppress=L6329
  group User
    ../User/source/: main.c Task_tim.c stm32f4xx_it.c
    ../User/include/: config.h
  group Hardware
    ../User/source/: Motor_Chassis.c Algorithm_pid.c Driver_DBUS.c Driver_can.c Driver_usart.c Driver_imu.c system_clock.c
  group Configeration
    ../Hardware/source/: INIT_TIM.c INIT_CAN.c INIT_SPI.c INIT_GPIO.c INIT_USART.c usbd_cdc_if.c usbd_conf.c usbd_desc.c stm32f4xx_hal_msp.c usb_device.c INIT_DMA.c
  group Libraries
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_pcd.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_can.c stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_hal_flash.c stm32f4xx_ll_usb.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_dma_ex.c
  group Middlewares/Drivers
    ../Drivers/Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Drivers/Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ./: startup_stm32f427xx.s
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group ReadMe
    ../: readme.txt
software components: CMSIS:CORE 5.0.1
